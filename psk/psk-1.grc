options:
  parameters:
    generate_options: qt_gui
    id: psk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dragon/Desktop/psk/output.bin
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '5'
    type: byte
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/dragon/Desktop/psk/challenge.wav
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '4'
    omega_relative_limit: '0.005'
    type: float
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_wavfile_source_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_skiphead_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
